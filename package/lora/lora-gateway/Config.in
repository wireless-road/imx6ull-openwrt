## package/lora/lora-gateway/Config.in
```kconfig
# libloragw configuration

if PACKAGE_libloragw

config SX1301_SPI_PATH
	string "SPI Dev Path"
	default /dev/spidev1.1

endif
```
